FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://0001-DDR_MEM-use-boardcnf-9-to-16GB.patch \
                   file://0002-LED-trun-off-led-on-boot.patch \
"

