FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DTS-change-ddr-ram-16GB-for-mai-board.patch file://0002-SDMMC-change-vcc-control-pin-for-sdmmc-channel-0.patch"

